options:
  parameters:
    author: Minhaj Ahmad
    description: Live PSD from a Pocket SDR FE RF channel
    generate_options: qt_gui
    id: pocketsdr_psd
    output_language: python
    title: PocketSDR FE Live PSD
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1575.42e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: pocketsdr_pocketsdr_source_0
  id: pocketsdr_pocketsdr_source
  parameters:
    channels: '[1]'
    comment: |-
      Leave Config File empty to use
      the current device settings
      (set with pocket_conf).
    conf_file: ''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    label1: GPS L1
    name: '"Pocket SDR FE CH1"'
    type: complex
  states: {}

connections:
- [pocketsdr_pocketsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
